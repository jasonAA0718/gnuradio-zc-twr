options:
  parameters:
    generate_options: qt_gui
    id: RX
    output_language: python
    title: ZC_RX
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 1400e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: zc_length
  id: variable
  parameters:
    value: '1399'
  states: {}
- name: zc_root
  id: variable
  parameters:
    value: '25'
  states: {}
- name: zc_seq_25
  id: variable
  parameters:
    value: np.exp(-1j * np.pi * int(25) * np.arange(zc_length) * (np.arange(zc_length) + 1) / zc_length).astype(np.complex64)
  states: {}
- name: zc_seq_31
  id: variable
  parameters:
    value: np.exp(-1j * np.pi *int(31)* np.arange(zc_length) * (np.arange(zc_length) + 1) / zc_length).astype(np.complex64)
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\nimport  packet_utils\n\n\nclass rtt_responder_advanced(gr.basic_block):\n    def __init__(\n        self,\n        zc_seq=np.array([1, 1]),\n        samp_rate=1e6,\n        delay_secs=0.5,\n        zc_length=839,\n        k_peak2noise=8,\n        fixed_threshold=200,\n    ):\n        gr.basic_block.__init__(\n            self,\n            name=\"RTT Responder Advanced\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64],\n        )\n        self.responder_id = 0x02  # Unique ID for this responder\n        self.zc_seq = zc_seq\n        self.samp_rate = samp_rate\n        self.delay = delay_secs\n        self.zc_length = zc_length\n        self.k_peak2noise = k_peak2noise\n        self.fixed_threshold = fixed_threshold\n        self.transmit_num = 0\n        self.measurement_number = 0\n\n        self.last_rx_time = None\n        self.last_tag_offset = 0\n\n        self.cooldown_secs = 0.001  # Wait 50 ms before sending again\n        self.cooldown_samples = int(self.cooldown_secs * self.samp_rate)\n\n        # Do not allow a reply too close to the start of the stream.\n        self.next_allowed_tx_offset = int(0.01 * self.samp_rate)\n\n        # BPSK settings\n        self.sps = 60  # Samples per symbol\n        # The total sequence length must accommodate ZC + gap + payload\n        self.n_bits = packet_utils.RESPONSE_PACKET_BITS\n        self.seq_len = zc_length + 100 + self.sps * self.n_bits  # ZC + gap + payload\n        # Set the out buffer minimum output buffer size to seq_len to ensure we can always produce a full burst\n        self.set_min_output_buffer(0, self.seq_len+1000)  # Add some extra margin\n        self.burst_data = np.zeros(self.seq_len, dtype=np.complex64)\n\n        self.burst_active = False\n        self.burst_pos = 0\n        self.burst_total_len = 0\n        self.pending_tx_time = None\n    def general_work(self, input_items, output_items):\n        in_sig = input_items[0]\n        out = output_items[0]\n\n        n_input = len(in_sig)\n\n        # 憒?銝???瘝\u0080?嚗?蝥嚗??菜葫??peak\n        if self.burst_active:\n            to_produce = self.output_burst_chunk(out)\n\n            self.consume(0, n_input)\n            self.produce(0, to_produce)\n            return gr.WORK_CALLED_PRODUCE\n\n        mag = np.abs(in_sig)\n        abs_start = self.nitems_read(0)\n\n        tags = self.get_tags_in_window(0, 0, n_input)\n        for tag in tags:\n            if pmt.symbol_to_string(tag.key) == \"rx_time\":\n                self.last_rx_time = tag.value\n                self.last_tag_offset = int(tag.offset)\n\n        peak_indices = self.find_peak_indices(mag)\n\n        if peak_indices is None:\n            self.consume(0, n_input)\n            return gr.WORK_CALLED_PRODUCE\n\n        peak_local = int(peak_indices)\n        current_peak_offset = int(abs_start + peak_local)\n\n        if self.last_rx_time is None:\n            print(\"[WARN] No rx_time tag available yet. Cannot timestamp T2.\")\n            self.consume(0, n_input)\n            return gr.WORK_CALLED_PRODUCE\n\n        rx_base_tick = int(packet_utils.pmt_time_to_ticks(self, self.last_rx_time))\n        diff_samples = int(current_peak_offset - self.last_tag_offset)\n\n        t2_correction_samples = int(getattr(self, \"t2_correction_samples\", 0))\n        t2_tick = int(rx_base_tick + diff_samples + t2_correction_samples - self.zc_length)\n\n        delay_samples = int(round(self.delay * self.samp_rate))\n        t3_tick = int(t2_tick + delay_samples)\n\n        tx_target_time = packet_utils.ticks_to_pmt_time(self, t3_tick)\n\n        if current_peak_offset < self.next_allowed_tx_offset:\n            self.consume(0, n_input)\n            return gr.WORK_CALLED_PRODUCE\n\n        ts_mask = (1 << packet_utils.T2_MINUS_T3_BITS) - 1\n        measurement_mask = (1 << packet_utils.MEASUREMENT_NUMBER_BITS) - 1\n\n        t2_minus_t3_payload = int((t2_tick - t3_tick) & ts_mask)\n        self.measurement_number = (self.measurement_number + 1) & measurement_mask\n\n        packet_bits = packet_utils.build_response_packet(\n            responder_id=int(self.responder_id),\n            t2_minus_t3=t2_minus_t3_payload,\n            measurement_number=self.measurement_number,\n        )\n\n        bpsk_samples = self.generate_bpsk(packet_bits, self.sps)\n        gap = np.zeros(100, dtype=np.complex64)\n\n        tail_guard = np.zeros(100, dtype=np.complex64)\n\n        self.burst_data = np.concatenate((\n            np.asarray(self.zc_seq, dtype=np.complex64),\n            gap,\n            np.asarray(bpsk_samples, dtype=np.complex64),\n            tail_guard,\n        )).astype(np.complex64)\n\n        self.burst_total_len = len(self.burst_data)\n        self.burst_pos = 0\n        self.burst_active = True\n        self.pending_tx_time = tx_target_time\n\n        self.next_allowed_tx_offset = current_peak_offset + self.cooldown_samples\n\n        to_produce = self.output_burst_chunk(out)\n\n        self.consume(0, n_input)\n        self.produce(0, to_produce)\n        return gr.WORK_CALLED_PRODUCE\n\n    def generate_bpsk(self, bits, sps):\n        symbols = [(-0.7 + 0j) if int(b) else (0.7 + 0j) for b in bits]\n        sym_array = np.asarray(symbols, dtype=np.complex64)\n        return np.repeat(sym_array, sps)\n\n    def find_peak_indices(self, in_sig):\n        magnitude = in_sig\n        noise_floor = np.mean(magnitude)\n        threshold = max(noise_floor * self.k_peak2noise, self.fixed_threshold)\n\n        candidate_indices = np.where(magnitude > threshold)[0]\n\n        if candidate_indices.size == 0:\n            return None\n        \n        peak_indices = candidate_indices[np.argmax(magnitude[candidate_indices])]\n\n        return peak_indices\n\n    def add_time(self, time_tuple, offset_secs):\n        secs = pmt.to_uint64(pmt.tuple_ref(time_tuple, 0))\n        frac = pmt.to_double(pmt.tuple_ref(time_tuple, 1))\n\n        new_frac = frac + offset_secs\n        full_secs = secs + int(new_frac)\n        remainder_frac = new_frac % 1.0\n        return pmt.make_tuple(pmt.from_uint64(full_secs), pmt.from_double(remainder_frac))\n\n    def issue_burst(self, out_buffer, tx_time):\n        self.add_item_tag(\n            0, self.nitems_written(0), pmt.intern(\"tx_time\"), tx_time, pmt.intern(\"resp\")\n        )\n        self.add_item_tag(\n            0, self.nitems_written(0), pmt.intern(\"tx_sob\"), pmt.PMT_T, pmt.intern(\"resp\")\n        )\n        self.add_item_tag(\n            0,\n            self.nitems_written(0) + self.seq_len - 1,\n            pmt.intern(\"tx_eob\"),\n            pmt.PMT_T,\n            pmt.intern(\"resp\"),\n        )\n        out_buffer[: self.seq_len] = self.burst_data[0:self.seq_len]\n\n    def output_burst_chunk(self, out_buffer):\n        n_output = len(out_buffer)\n\n        remaining = self.burst_total_len - self.burst_pos\n        to_copy = min(remaining, n_output)\n\n        start = self.burst_pos\n        end = start + to_copy\n\n        out_buffer[:to_copy] = self.burst_data[start:end]\n\n        abs_out_start = self.nitems_written(0)\n\n        # 蝚砌?畾菜???tx_time ??tx_sob\n        if start == 0:\n            self.transmit_num = self.transmit_num +1\n            print(\"TX\",self.transmit_num )\n            self.add_item_tag(\n                0,\n                abs_out_start,\n                pmt.intern(\"tx_time\"),\n                self.pending_tx_time,\n                pmt.intern(\"resp\"),\n            )\n            self.add_item_tag(\n                0,\n                abs_out_start,\n                pmt.intern(\"tx_sob\"),\n                pmt.PMT_T,\n                pmt.intern(\"resp\"),\n            )\n\n        self.burst_pos = end\n\n        # ?\u0080敺?畾菜???tx_eob\n        if self.burst_pos >= self.burst_total_len:\n            self.add_item_tag(\n                0,\n                abs_out_start + to_copy - 1,\n                pmt.intern(\"tx_eob\"),\n                pmt.PMT_T,\n                pmt.intern(\"resp\"),\n            )\n\n            self.burst_active = False\n            self.burst_pos = 0\n            self.burst_total_len = 0\n            self.pending_tx_time = None\n\n        return to_copy\n"
    delay_secs: '0.005'
    fixed_threshold: '150'
    k_peak2noise: '25'
    samp_rate: samp_rate
    zc_length: zc_length
    zc_seq: zc_seq_31
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          

          def __init__(self, zc_length =839,k_peak2noise=8,fixed_threshold=200):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Peak Detect Jason',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.int8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.zc_length = zc_length
              self.k_peak2noise = k_peak2noise
              self.fixed_threshold = fixed_threshold
              self.noise = 0


          def work(self, input_items, output_items):
              in_sig = input_items[0]
              n_input = len(in_sig)
              output_items[0][:] = input_items[0][:]*0  # 清空輸出
              n_out = len(output_items[0])
              # 
              magnitude = np.fabs(in_sig)
              noise_floor = sum(in_sig)/n_input
              peaks_index = np.where(magnitude > noise_floor * self.k_peak2noise)[0]
              peak_candidates = []
              for peak in peaks_index:
                  if magnitude[peak] > self.fixed_threshold:
                      peak_candidates.append(peak)
                       # 只保留峰值位置的信號
                      output_items[0][peak] = input_items[0][peak]/np.abs(input_items[0][peak])


              # Second peak ratio test
              # if len(peak_candidates) > 1:

                  
              return n_out
    fixed_threshold: '350'
    k_peak2noise: '50'
    zc_length: zc_length
  states: {state: disabled}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: np.conj(zc_seq_25[::-1])
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*8
    fc: '0'
    fftsize: '1024'
    name: '"Output"'
    tr_level: '-80'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '1'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 2*samp_rate
    fc: '0'
    fftsize: '512'
    grid: 'True'
    name: '"Input"'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Convlution output"'
    size: zc_length
    srate: samp_rate
    tr_level: '100'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.1'
    ymax: '500'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '1'
    ymax: '2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Input"'
    size: '1024'
    srate: samp_rate
    tr_level: '0.8'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '1'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"output"'
    size: '1343'
    srate: samp_rate
    tr_level: '0.01'
    type: complex
    update_time: '1'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: freq
    dev_addr: '"serial=34D0564"'
    gain0: gain
    gain_type0: normalized
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: freq
    dev_addr: '"serial=34D0564"'
    dev_args: '"recv_buff_size=1200000,num_recv_frames=512"'
    gain0: '1'
    gain_type0: normalized
    rx_agc0: Disabled
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_complex_to_mag_0, '0', epy_block_1, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0_0_1_0, '0']
- [epy_block_0, '0', uhd_usrp_sink_0, '0']
- [epy_block_1, '0', blocks_char_to_float_0, '0']
- [fft_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [fft_filter_xxx_0, '0', epy_block_0, '0']
- [uhd_usrp_source_0, '0', fft_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
