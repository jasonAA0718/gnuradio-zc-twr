options:
  parameters:
    description: One-way OFDM PRS receiver estimator at 10 MHz and 1399 MHz
    generate_options: qt_gui
    id: prs_rx_estimator_10M_1399
    output_language: python
    title: PRS RX Estimator 10M 1399
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1399e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: prs_channel_estimator_0
  id: ofdm_prs_ranging_prs_channel_estimator
  parameters:
    active_bins: '600'
    fft_len: '1024'
    prs_symbols: '16'
    samp_rate: samp_rate
    seed: '13990001'
  states: {}
- name: prs_csv_logger_0
  id: ofdm_prs_ranging_prs_csv_logger
  parameters:
    append: 'True'
    path: '"prs_measurements.csv"'
  states: {}
- name: prs_fft_receiver_0
  id: ofdm_prs_ranging_prs_fft_receiver
  parameters:
    active_bins: '600'
    cp_len: '128'
    fft_len: '1024'
    prs_symbols: '16'
    samp_rate: samp_rate
  states: {}
- name: prs_frame_detector_0
  id: ofdm_prs_ranging_prs_frame_detector
  parameters:
    active_bins: '600'
    coarse_sync_len: '839'
    cp_len: '128'
    fft_len: '1024'
    min_frame_gap: '10000'
    preamble_len: '128'
    preamble_repeats: '16'
    prs_symbols: '16'
    samp_rate: samp_rate
    tail_guard_len: '1000'
    threshold: '0.35'
    zero_guard_len: '1000'
  states: {}
- name: prs_phase_slope_estimator_0
  id: ofdm_prs_ranging_prs_phase_slope_estimator
  parameters:
    active_bins: '600'
    fft_len: '1024'
    max_residual_rms: '1.0'
    samp_rate: samp_rate
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: '"serial=34D0563"'
    dev_args: '"recv_buff_size=20000000,num_recv_frames=700"'
    gain0: rx_gain
    gain_type0: normalized
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: sync
    type: fc32
  states: {}

connections:
- [prs_channel_estimator_0, channel_out, prs_phase_slope_estimator_0, channel_in]
- [prs_fft_receiver_0, symbols_out, prs_channel_estimator_0, symbols_in]
- [prs_frame_detector_0, frame_out, prs_fft_receiver_0, frame_in]
- [prs_phase_slope_estimator_0, measurement_out, prs_csv_logger_0, measurement_in]
- [uhd_usrp_source_0_0, '0', prs_frame_detector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
