options:
  parameters:
    comment: Minimal SS-RTT responder topology. Add/configure UHD Source and Sink for hardware.
    description: Minimal OFDM PRS SS-RTT responder at 10 MHz and 1399 MHz
    generate_options: no_gui
    id: prs_ssrtt_responder_10M_1399
    output_language: python
    title: PRS SS-RTT Responder 10M 1399
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1399e6
  states: {}
- name: reply_delay_samples
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: prs_channel_estimator_0
  id: ofdm_prs_ranging_prs_channel_estimator
  parameters:
    active_bins: '600'
    fft_len: '1024'
    prs_symbols: '16'
    samp_rate: samp_rate
    seed: '13990001'
  states: {}
- name: prs_fft_receiver_0
  id: ofdm_prs_ranging_prs_fft_receiver
  parameters:
    active_bins: '600'
    cp_len: '128'
    fft_len: '1024'
    prs_symbols: '16'
    samp_rate: samp_rate
  states: {}
- name: prs_frame_detector_0
  id: ofdm_prs_ranging_prs_frame_detector
  parameters:
    active_bins: '600'
    coarse_sync_len: '839'
    comment: Connect UHD Source here
    cp_len: '128'
    fft_len: '1024'
    min_frame_gap: '10000'
    preamble_len: '128'
    preamble_repeats: '16'
    prs_symbols: '16'
    samp_rate: samp_rate
    tail_guard_len: '1000'
    threshold: '0.35'
    zero_guard_len: '1000'
  states: {}
- name: prs_acquisition_logger_0
  id: ofdm_prs_ranging_prs_acquisition_logger
  parameters:
    append: '1'
    comment: Logs every detected POLL before responder filtering
    node: '"responder"'
    path: '"CSV/responder_acquisition.csv"'
  states: {}
- name: prs_phase_slope_estimator_0
  id: ofdm_prs_ranging_prs_phase_slope_estimator
  parameters:
    active_bins: '600'
    fft_len: '1024'
    max_residual_rms: '1.0'
    samp_rate: samp_rate
  states: {}
- name: prs_source
  id: ofdm_prs_ranging_prs_timed_burst_source
  parameters:
    active_bins: '600'
    attach_tx_time: 'True'
    burst_period: '0.1'
    coarse_sync_len: '839'
    cp_len: '128'
    fft_len: '1024'
    pings_per_trigger: '1'
    preamble_len: '128'
    preamble_repeats: '16'
    prs_symbols: '16'
    samp_rate: samp_rate
    seed: '13990001'
    tail_guard_len: '1000'
    tx_amp: '0.2'
    tx_lead_time: '0.01'
    zero_guard_len: '1000'
  states: {}
- name: prs_ssrtt_responder_0
  id: ofdm_prs_ranging_prs_ssrtt_responder
  parameters:
    reply_delay_samples: reply_delay_samples
    samp_rate: samp_rate
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: '"serial=34D0564"'
    gain0: '0.5'
    gain_type0: normalized
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: '"serial=34D0564"'
    dev_args: '"recv_buff_size=20000000,num_recv_frames=700"'
    gain0: '0.6'
    gain_type0: normalized
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: sync
    type: fc32
  states: {}

connections:
- [prs_channel_estimator_0, channel_out, prs_phase_slope_estimator_0, channel_in]
- [prs_fft_receiver_0, symbols_out, prs_channel_estimator_0, symbols_in]
- [prs_frame_detector_0, frame_out, prs_acquisition_logger_0, frame_in]
- [prs_frame_detector_0, frame_out, prs_fft_receiver_0, frame_in]
- [prs_phase_slope_estimator_0, measurement_out, prs_ssrtt_responder_0, measurement_in]
- [prs_source, '0', uhd_usrp_sink_0, '0']
- [prs_ssrtt_responder_0, trigger_out, prs_source, trigger]
- [uhd_usrp_source_0_0, '0', prs_frame_detector_0, '0']
- [uhd_usrp_source_0_0, '0', prs_source, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
